require astertom-core-image.bb

IMAGE_FEATURES:append = "debug-tweeks"
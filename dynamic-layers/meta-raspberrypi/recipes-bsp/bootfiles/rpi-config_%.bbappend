do_deploy:append() {
    # Enable RPI 7' touchscreen display
    echo "display_auto_detect=1" >> $CONFIG
}
